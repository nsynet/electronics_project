# IAR project usart_sendshuzhi_520.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxD ST STM32F10xxD
  ICCARM.CCIncludePath2: EWARM_V2.0.2\library\inc\; EWARM_V2.0.2; ; TCPIP\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: usart_sendshuzhi_520.srec
  ILINK.IlinkOutputFile: usart_sendshuzhi_520.out
  ILINK.IlinkIcfFile: EWARM_V2.0.2\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    EWARM_V2.0.2/: cortexm3_macro.s stm32f10x_vector.c
  group FWlib
    EWARM_V2.0.2/library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group TCPIP
    TCPIP/: ENC28J60.C ip_arp_udp_tcp.c simple_server.c SPI.C
  group User
    ./: main.c stm32f10x_it.c user_uart.c
