# Keil uVision project STM32电子相册.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32电子相册 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FatFs;..\Fwlib\inc;..\LCD;..\Malloc;..\Picture;..\System;..\USER;..\KEY;..\SD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group FatFs
    ../FatFs/: diskio.c exfuns.c ff.c
    ../FatFs/option/: cc936.c
  group Fwlib
    ../Fwlib/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group LCD
    ../LCD/: LCD.c
  group Malloc
    ../Malloc/: malloc.c
  group Picture
    ../Picture/: bmp.c piclib.c tjpgd.c
  group USER
    ../USER/: main.c stm32f10x_it.c
  group System
    ../System/: delay.c sys.c
  group KEY
    ../KEY/: key.c
  group SD
    ../SD/: SD.C spi.c
