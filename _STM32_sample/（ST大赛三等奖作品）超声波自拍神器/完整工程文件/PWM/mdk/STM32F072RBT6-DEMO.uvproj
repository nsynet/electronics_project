# Keil uVision project STM32F072RBT6-DEMO.uvproj, settings and files
target STM32F072RBT6-PWM (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072
  c misc: --C99
  c include: ..\;..\..\;..\driver;..\lib;..\lib\inc;..\lib\src;..\startup;..\user;..\stm32f072rbt6
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group startup
    ../startup/: startup_stm32f072.s
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group driver
    ../driver/: LED.C NVIC.C KEY.C PWM.C
  group user
    ../user/: main.c
    ../stm32f072rbt6/: system_stm32f0xx.c stm32f0xx_it.c
