<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GokitShield_Nucleo64_STM32L073RZ.ewp</path>
  </project>
  <batchBuild />
</workspace>
