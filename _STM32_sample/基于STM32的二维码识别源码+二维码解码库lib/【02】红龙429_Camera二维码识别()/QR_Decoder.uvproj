# Keil uVision project QR_Decoder.uvproj, settings and files
target QR_Decoder (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: Test
  c flags: Optim=1 OneElfS=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;.\Driver;.\Application;.\FATFS;.\FATFS\option;.\QR_Decoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries/CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Driver/: startup_stm32f429_439xx.s
  group Libraries/StdPeriph_Driver_v1.5.0
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_fmc.c stm32f4xx_dma2d.c stm32f4xx_ltdc.c stm32f4xx_i2c.c stm32f4xx_rtc.c stm32f4xx_dcmi.c
  group Driver
    ./Driver/: delay.c Gpio.c USART.c ov7670.c ov2640.c ov5642.c mt9d111.c sccb_bus.c WB_LOGO.c stm32f429i_sdram.c stm32f429i_lcd.c RTC.c stm32f42x_sd.c
  group Application
    ./Application/: main.c stm32f4xx_it.c
  group QR_Decoder
    ./QR_Decoder/: QR-Core.lib
